<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HW_VCP_Sniffer.ewp</path>
  </project>
  <batchBuild />
</workspace>
